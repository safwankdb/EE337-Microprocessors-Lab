ORG 0000H
LJMP MAIN

ORG 50H
ADDER_16BIT:
	ADD A, R0
	MOV 64H, A
	MOV A, R1
	ADDC A, R2
	MOV 63H, A
	RL A
	ANL A, #1
	MOV 62H,A
	RET

INIT:
	MOV 61H, #0x01
	MOV 60H, #0X7F
	MOV 71H, #0x11
	MOV 70H, #0X01
	MOV R0, 71h
	MOV R1, 60H
	MOV R2, 70H
	MOV A, 61H
	RET

ORG 0100H
MAIN:
	ACALL INIT
	ACALL ADDER_16BIT
LOOP:  
	SJMP LOOP
END
