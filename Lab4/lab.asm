ORG 00H
	LJMP MAIN
	
; delay of 1 sec
DELAY:
	MOV R3, #20
	BACK0:
		MOV R2, #200
		BACK1:
			MOV R1, #0FFH
			BACK:
				DJNZ R1, BACK
			DJNZ R2, BACK1
		DJNZ R3, BACK0
	RET

READNIBBLE:
	MOV P1, #0FFH
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
	ANL P1, #00FH
	LCALL DELAY
	MOV A, P1
	ANL A, #00FH
	MOV @R0, A
	RL A
	RL A
	RL A
	RL A
	MOV P1, A
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
	RET

PACKNIBBLES:
	MOV A, 4EH
	RL A
	RL A
	RL A
	RL A
	ADD A, 4FH
	MOV 50H, A
	RET

ORG 100H

MAIN:
	MOV R0, #4EH
	LCALL READNIBBLE
	MOV R0, #4FH
	LCALL READNIBBLE
	LCALL PACKNIBBLES
END