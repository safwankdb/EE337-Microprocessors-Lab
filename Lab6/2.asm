ORG 00H
	LJMP MAIN
ORG 100H
	MAIN:
		MOV A, P1
		ANL A, #07H
		ADD A, #2
		MOV R2, #10
		LOOP:
			MOV TH1, #-06H
			CJNE A, #0, NOTZERO
			ZERO:
				CLR P3.2
				SETB TR1
				ACALL DELAY
			DJNZ R2, LOOP
			LJMP MAIN
			NOTZERO:
				DEC A
				SETB P3.2
				SETB TR1
				ACALL DELAY	
			DJNZ R2, LOOP
		LJMP MAIN
		
	DELAY:
		JNB TF1, DELAY
		CLR TF1
		CLR TR1
		RET	
END